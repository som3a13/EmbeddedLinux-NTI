## Linux Admin/Day11/AbdEL3al Task/simpleapp/Config.in
```kconfig
config BR2_PACKAGE_SIMPLEAPP
    bool "simpleapp"
    help
        simpleapp package.
```
